# Autodesk Inventor assembly: Z-2531-Test Z
## iProperties
Created: 2009-11
Part Number: Z-2531-Test Z
Document SubType Name: Assembly
Designer: Strathkötter
Author: Strathkötter
